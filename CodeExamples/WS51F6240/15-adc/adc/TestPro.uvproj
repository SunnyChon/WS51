# Keil uVision project TestPro.uvproj, settings and files
target Target 1 (MCS-51)
  device: WS51F7030 WS51
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0x1FF) CLOCK(16000000)
  output: TestPro +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\headfile;..\..\hareware
  group user
    ./: STARTUP.A51 main.c
  group hareware
    ../../hareware/: uart1.c ADC.c
